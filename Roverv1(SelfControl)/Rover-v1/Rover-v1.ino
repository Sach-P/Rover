//#include <IRremote.h>
unsigned char Bluetooth_val;


int inputPin=A0; //Echo
int outputPin=A1; //Trig
int RECV_PIN = 2;

/*
IRrecv irrecv(RECV_PIN);
decode_results results;               //IR Reciever Buttons
#define IR_Go      0x00ff629d
#define IR_Back    0x00ffa857
#define IR_Left    0x00ff22dd
#define IR_Right   0x00ffc23d 
#define IR_Stop    0x00ff02fd
#define IR_ESC     0x00ff52ad
#define IR_One     0x00ff6897
*/
#define Lpwm_pin 5
#define Rpwm_pin 8

int pinLB=3;
int pinLF=4;
int pinRB=6;
int pinRF=7;
unsigned char Lpwm_val = 255;
unsigned char Rpwm_val = 255;
int Car_state=0;
int servopin=12;
int myangle;
int pulsewidth;
unsigned char DuoJiao=60;

bool selfControl = false;

void setup() {
  pinMode(servopin,OUTPUT);
  M_Control_IO_config();
  Set_Speed(Lpwm_val,Rpwm_val);
  Set_servopulse(DuoJiao);
  pinMode(inputPin, INPUT);
  pinMode(outputPin, OUTPUT);
  //irrecv.enableIRIn();
  Serial.begin(9600);
  stopp();

}


void loop() {

  
/*  if (irrecv.decode(&results)){
    if(results.value == IR_Stop )IR_Control();
    irrecv.resume();
  }
  */
  if(Serial.available()){
    Bluetooth_val=Serial.read();

    switch(Bluetooth_val){
      case 'F':
        advance();
        selfControl = false;
      break;
      case 'B':
        back();
        selfControl = false;
      break;
      case 'L':
        turnL();
        selfControl = false;
      break;
      case 'R':
        turnR();
        selfControl = false;
      break;
      case 'S':
        stopp();
        selfControl = false;
      break;
      case 'C':selfControl = true;
      break;
      default:
      break;
    }
  }
  if(selfControl){
    Self_Control();
  }
   
}

void servopulse(int servopin, int myangle){
  pulsewidth=(myangle*11)+500;
  digitalWrite(servopin,HIGH);
  delayMicroseconds(pulsewidth);
  digitalWrite(servopin,LOW);
  delay(20-pulsewidth/1000);
}
void Set_servopulse(int set_val){
  for(int i=0;i<=10;i++)
   servopulse(servopin,set_val);
}
void M_Control_IO_config(void){

  pinMode(pinLB,OUTPUT);
  pinMode(pinLF,OUTPUT);
  pinMode(pinRB,OUTPUT);
  pinMode(pinRF,OUTPUT);
  pinMode(Rpwm_pin,OUTPUT);
  pinMode(Lpwm_pin,OUTPUT);
}
void Set_Speed(unsigned char Left,unsigned char Right){
  analogWrite(Lpwm_pin,Left);
  analogWrite(Rpwm_pin,Right);
 
}
void advance(){
  digitalWrite(pinRB,HIGH);
  digitalWrite(pinRF,LOW);
  digitalWrite(pinLB,HIGH);
  digitalWrite(pinLF,LOW);
  Car_state = 1;
}
void turnR(){
  digitalWrite(pinRB,LOW);
  digitalWrite(pinRF,HIGH);
  digitalWrite(pinLB,HIGH);
  digitalWrite(pinLF,LOW);
  Car_state = 4;
}
void turnL(){
  digitalWrite(pinRB,HIGH);
  digitalWrite(pinRF,LOW);
  digitalWrite(pinLB,LOW);
  digitalWrite(pinLF,HIGH);
  Car_state = 3;
}
void stopp(){
  digitalWrite(pinRB,HIGH);
  digitalWrite(pinRF,HIGH);
  digitalWrite(pinLB,HIGH);
  digitalWrite(pinLF,HIGH);
  Car_state = 5;
}
void back(){
  digitalWrite(pinRB,LOW);
  digitalWrite(pinRF,HIGH);
  digitalWrite(pinLB,LOW);
  digitalWrite(pinLF,HIGH);
  Car_state = 2;
}

void Self_Control(void){  
  
  int H;

  Set_servopulse(DuoJiao);

  H = Ultrasonic_Ranging(1);
  delay(300);
  if(Ultrasonic_Ranging(1) < 35){
    stopp();
    delay(100);
    back();
    delay(50);
  }

  if(Ultrasonic_Ranging(1) < 60)
  {
    stopp();
    delay(100);
    Set_servopulse(5);
    int L = ask_pin_L(2);
    delay(300);
    Set_servopulse(177);
    int R = ask_pin_R(3);
    delay(300);

    if(ask_pin_L(2) > ask_pin_R(3)){
      back();
      delay(100);
      turnL();
      delay(400);
      stopp();
      delay(50);
      Set_servopulse(DuoJiao);
      H = Ultrasonic_Ranging(1);
      delay(500);
    }

      if(ask_pin_L(2) <= ask_pin_R(3)){
      back();
      delay(100);
      turnR();
      delay(400);
      stopp();
      delay(50);
      Set_servopulse(DuoJiao);
      H = Ultrasonic_Ranging(1);
      delay(300);
    }
    if(ask_pin_L(2) < 35 && ask_pin_R(3)< 35){
      stopp();
      delay(50);
      back();
     delay(50);
    }
  }
  else
  {
    advance();
  }
}
int Ultrasonic_Ranging(unsigned char Mode)
{
  int old_distance;
  digitalWrite(outputPin, LOW);
  delayMicroseconds(2);
  digitalWrite(outputPin, HIGH);
  delayMicroseconds(10);
  digitalWrite(outputPin, LOW);
  int distance = pulseIn(inputPin, HIGH);
  distance = distance/58;
  if(Mode==1){
    Serial.print("\n H = ");
    Serial.print(distance,DEC);
    return distance;
  }
  else return distance;
 
}

int ask_pin_L(unsigned char Mode)
{
  int old_Ldistance;
  digitalWrite(outputPin, LOW);
  delayMicroseconds(2);
  digitalWrite(outputPin, HIGH);
  delayMicroseconds(10);
  digitalWrite(outputPin, LOW);
  int Ldistance = pulseIn(inputPin, HIGH);
 Ldistance = Ldistance/58;
  if(Mode==2){
    Serial.print("\n L = ");
    Serial.print(Ldistance,DEC);
    return Ldistance;
  }
  else return Ldistance;
 
}
int ask_pin_R(unsigned char Mode)
{
  int old_Rdistance;
  digitalWrite(outputPin, LOW);
  delayMicroseconds(2);
  digitalWrite(outputPin, HIGH);
  delayMicroseconds(10);
  digitalWrite(outputPin, LOW);
  int Rdistance = pulseIn(inputPin, HIGH);
  Rdistance = Rdistance/58;
  if(Mode==3){
    Serial.print("\n R = ");
    Serial.print(Rdistance,DEC);
    return Rdistance;
  }
  else return Rdistance;
 
}
/*
void IR_Control(void)
{
   unsigned long Key;

  while(Key!=IR_ESC){
    if(irrecv.decode(&results))
    {
       Key = results.value;
      switch(Key)
      {
        case IR_Go: advance();
        break;
        case IR_Back: back();
        break;
        case IR_Left: turnL();
        break;
        case IR_Right: turnR();
        break;
        case IR_Stop: stopp();
        break;
        default:
        break;
        
      }
      irrecv.resume();
    }
  }
  stopp();
}
*/

